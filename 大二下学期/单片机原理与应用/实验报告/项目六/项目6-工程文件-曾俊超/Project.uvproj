# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Lcd1602.c keyboard.c intrins.h Lcd1602.h keyboard.h
    ../../项目五/项目5-工程文件-曾俊超/: config.h
