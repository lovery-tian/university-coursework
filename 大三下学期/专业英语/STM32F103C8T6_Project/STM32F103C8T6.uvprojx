# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\User;.\CMSIS;.\StdPeriph_Driver\inc
  group User
    ./User/: main.c stm32f10x_it.c stm32f10x_conf.h
  group CMSIS
    ./CMSIS/: system_stm32f10x.c
  group Startup
    ./CMSIS/startup/: startup_stm32f103xb.s
  group StdPeriph_Driver
    ./StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c misc.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
